# Keil uVision project BuckPowerHMI.uvprojx, settings and files
target BuckPowerHMI (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BuckPowerHMI +hex
  AfterMake: D:\Keil\ARM\ARM_Compiler_5.06u7\bin\fromelf.exe --bin -o F:\MyProjects\DigitalPower\HMI\User\Objects\BuckPowerHMI.bin  F:\MyProjects\DigitalPower\HMI_Code\User\Objects\BuckPowerHMI.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Library\inc;..\Hardware;..\Core;..\System\sys;..\RT_Thread_Nano\include;..\RT_Thread_Nano\libcpu\arm\cortex-m3;..\User;..\RT_Thread_Nano\bsp\_template
  asm include: ..\RT_Thread_Nano\libcpu\arm\cortex-m3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Core
    ../Core/: core_cm3.c core_cm3.h startup_stm32f10x_ld.s
  group Library
    ../Library/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../System/sys/: sys.c sys.h
  group Hardware
    ../Hardware/: AHT20.c AHT20.h Button.c Button.h Buzzer.c Buzzer.h CAN.c CAN.h DMA.c DMA.h Flash.c Flash.h IIC.c IIC.h Interface.c Interface.h Lcd.c Lcd.h LcdFont.h PID.c PID.h PWM.c PWM.h Tool.c Tool.h Usart.c Usart.h var.c var.h
  group RT-Thread/include
    ../RT_Thread_Nano/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtservice.h rtthread.h
    ../RT_Thread_Nano/bsp/_template/: board.c rtconfig.h
    ../RT_Thread_Nano/libcpu/arm/cortex-m3/: context_rvds.S
  group RT-Thread/src
    ../RT_Thread_Nano/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../RT_Thread_Nano/libcpu/arm/cortex-m3/: cpuport.c
  group User
    ./: stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c system_stm32f10x.c system_stm32f10x.h
